# Keil uVision project proceduce.uvprojx, settings and files
target proceduce (5060960::V5.06 update 7 (build 960)::.\ARM_COMFILE_5.06)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: proceduce +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;C:/Users/q2352/.stm32cubemx/Repository/STM32Cube_FW_F1_V1.8.5/Drivers/STM32F1xx_HAL_Driver/Inc;C:/Users/q2352/.stm32cubemx/Repository/STM32Cube_FW_F1_V1.8.5/Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;C:/Users/q2352/.stm32cubemx/Repository/STM32Cube_FW_F1_V1.8.5/Drivers/CMSIS/Device/ST/STM32F1xx/Include;C:/Users/q2352/.stm32cubemx/Repository/STM32Cube_FW_F1_V1.8.5/Drivers/CMSIS/Include;./hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/User/Core
    ../Core/Src/: main.c gpio.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    ./hardware/: Car_Control.c Car_Control.h
  group Drivers/STM32F1xx_HAL_Driver
    C:/Users/q2352/.stm32cubemx/Repository/STM32Cube_FW_F1_V1.8.5/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ./: startup_stm32f103xb.s
    ../Core/Src/: system_stm32f1xx.c
  group hardware
    ./hardware/: motor.c motor.h uart.h uart.c HC_SR04.c HC_SR04.h infrared.c infrared.h hx711.c hx711.h delay.c delay.h
software components: CMSIS:CORE 4.3.0
